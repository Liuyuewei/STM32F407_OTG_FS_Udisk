# Keil uVision project Project.uvproj, settings and files
target STM32F407_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407-EVAL +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,USE_USB_OTG_FS
  c include: ..\MDK-ARM;..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\STM32F407-EVAL;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\Binary;..\..\Project;..\..\Utilities\STM32_EVAL\System;..\..\Utilities\STM32_EVAL\STM32F407_EVAL;..\..\Utilities\STM32_EVAL\Hardware;..\..\Libraries\STM32_USB-Host-Device_Lib_V2.1.0\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB-Host-Device_Lib_V2.1.0\STM32_USB_Device_Library\Class\msc\inc;..\..\fat_fs\src;..\..\fat_fs\inc;..\..\uCGUI\Core;..\..\lcd;..\..\Fonts;..\..\App;..\..\Libraries\STM32_USB-Host-Device_Lib_V2.1.0\STM32_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../App/: udisk.c bsp_nand_flash.c flash_if.c main.c Uart_communication.c usb_bsp.c usbd_desc.c usbd_storage_template.c usbd_usr.c
    ../../FAT12/: fat.c
  group STM32F4xx
    ../: system_stm32f4xx.c startup_stm32f40xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_it.c
  group STM32_USB_OTG_Driver
    ../../Libraries/STM32_USB-Host-Device_Lib_V2.1.0/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32_USB_Device_Library
    ../../Libraries/STM32_USB-Host-Device_Lib_V2.1.0/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB-Host-Device_Lib_V2.1.0/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group LCD
    ../../lcd/: LCD_RA8875.c
